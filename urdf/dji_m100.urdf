Commit message: updating repo

File: urdf/dji_m100.urdf (robot description, URDF)
Before this commit: robot DJI_Matrice_100, 1 links, 0 joints
Links:
- link robot_base_link: geometry visual mesh filename=package://ars_robot_models/meshes/dji_m100.dae scale=0.01 0.01 0.01
